# Keil uVision project Examples.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Flash13 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=4
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD,LFS_NO_MALLOC,LFS_NO_DEBUG,LFS_NO_WARN,LFS_NO_ERROR
  c include: .;..\..\..\Start;..\..\..\Library;..\..\..\Core;..\..\..\System;..\..\..\Debug;..\..\..\Common;..\..\..\Drivers\basic;..\..\..\Drivers\display;..\..\..\Drivers\i2c;..\..\..\Drivers\spi;..\..\..\Drivers\flash;..\..\..\Drivers\uart;..\..\..\Drivers\timer;..\..\..\Drivers\analog;..\..\..\Drivers\peripheral;..\..\..\Drivers\dma;..\..\..\Drivers\motor;..\..\..\Middlewares\storage\littlefs;..\..\..\Middlewares\storage\fs_wrapper;..\..\..\Tools\font_uploader
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group BSP
    ./: board.h
  group Drivers
    ../../../Drivers/basic/: gpio.c gpio.h buzzer.c buzzer.h led.c led.h
    ../../../Drivers/display/: oled_ssd1306.c oled_ssd1306.h oled_font_ascii8x16.c oled_font_ascii8x16.h oled_font_chinese16x16.c oled_font_chinese16x16.h oled_utf8_parser.c oled_utf8_parser.h
    ../../../Drivers/i2c/: i2c_sw.c i2c_sw.h
    ../../../Drivers/timer/: TIM2_TimeBase.c TIM2_TimeBase.h timer_pwm.c timer_pwm.h
    ../../../Drivers/uart/: uart.c uart.h
    ../../../Drivers/spi/: spi_hw.c spi_hw.h
    ../../../Drivers/flash/: w25q_spi.c w25q_spi.h
    ../../../Middlewares/storage/littlefs/: littlefs_wrapper.c littlefs_wrapper.h
    ../../../Middlewares/storage/fs_wrapper/: fs_wrapper.c fs_wrapper.h
    ../../../Tools/font_uploader/: font_uploader.c font_uploader.h
    ../../../Drivers/peripheral/: exti.c exti.h
    ../../../Drivers/motor/: tb6612.c tb6612.h
  group Middlewares
    ../../../Middlewares/storage/littlefs/: lfs.c lfs.h lfs_util.c lfs_util.h
  group common
    ../../../Common/: error_code.h error_handler.c
  group Core
    ../../../Core/: stm32f10x_it.h stm32f10x_conf.h stm32f10x_it.c
    ./: main_example.c
  group system
    ./: config.h
    ../../../System/: delay.c delay.h system_init.c system_init.h
  group Library
    ../../../Library/: misc.c misc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_spi.c stm32f10x_spi.h
  group Start
    ../../../Start/: startup_stm32f10x_md.s core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Debug
    ../../../Debug/: assert.c assert.h debug.c debug.h log.c log.h printf_wrapper.c printf_wrapper.h
