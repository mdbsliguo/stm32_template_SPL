# Keil uVision project Examples.uvprojx, settings and files
target NPN06_Preset_Pump_HwAlgo_STM32F103ZE (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: NPN06_Preset_Pump_HwAlgo_STM32F103ZE +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .;..\..\..\Start;..\..\..\Library;..\..\..\Core;..\..\..\System;..\..\..\Debug;..\..\..\Common;..\..\..\Drivers\basic;..\..\..\Drivers\display;..\..\..\Drivers\i2c;..\..\..\Drivers\uart;..\..\..\Drivers\timer;..\..\..\Drivers\analog;..\..\..\Drivers\peripheral;..\..\..\Drivers\dma;..\..\..\Drivers\motor;..\..\..\Drivers\sensors;..\..\..\Middlewares\protocols\modbus_rtu
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group BSP
    ./: board.h board_early_init.c board_early_init.h
  group Drivers
    ../../../Drivers/basic/: gpio.c gpio.h buzzer.c buzzer.h led.c led.h
    ../../../Drivers/display/: oled_ssd1306.c oled_ssd1306.h oled_font_ascii8x16.c oled_font_ascii8x16.h
    ../../../Drivers/i2c/: i2c_hw.c i2c_hw.h
    ../../../Drivers/timer/: TIM2_TimeBase.c TIM2_TimeBase.h ogm_flow_ic.c ogm_flow_ic.h
    ../../../Drivers/uart/: uart.c uart.h
    ../../../Drivers/peripheral/: nvic.c nvic.h
  group Middlewares
    ../../../Middlewares/protocols/modbus_rtu/: modbus_rtu.c modbus_rtu.h
  group common
    ../../../Common/: error_code.h error_handler.c
  group Core
    ../../../Core/: stm32f10x_it.h stm32f10x_conf.h stm32f10x_it.c
    ./: main_example.c
  group system
    ./: config.h
    ../../../System/: delay.c delay.h system_init.c system_init.h TIM_sw.c TIM_sw.h
  group Library
    ../../../Library/: misc.c misc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h
  group Start
    ../../../Start/: startup_stm32f10x_hd.s core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Debug
    ../../../Debug/: assert.c assert.h debug.c debug.h log.c log.h printf_wrapper.c printf_wrapper.h
