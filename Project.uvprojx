# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\Start;.\Library;.\Core;.\BSP;.\system;.\Debug;.\common;.\Drivers\basic;.\Drivers\i2c;.\Drivers\spi;.\Drivers\display;.\Drivers\sensors
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ./Start/: startup_stm32f10x_md.s core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Library
    ./Library/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group BSP
    ./BSP/: board.h
  group system
    ./system/: base_TIM2.c base_TIM2.h delay.c delay.h clock_manager.c clock_manager.h iwdg.c iwdg.h module_controller.c module_controller.h README.md system_init.c system_init.h system_monitor.c system_monitor.h
  group Debug
    ./Debug/: debug.c debug.h log.c log.h assert.c assert.h
  group modules
    ./Drivers/basic;./Drivers/i2c;./Drivers/spi;./Drivers/display;./Drivers/sensors/: gpio.c gpio.h led.c led.h
    ./Drivers/display/: oled_ssd1306.c oled_ssd1306.h oled_font_ascii8x16.c oled_font_ascii8x16.h
  group common
    ./common/: error_code.h error_handler.c error_handler.h cpu_load_simulator.c cpu_load_simulator.h
  group Core
    ./Core/: stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h main.c
